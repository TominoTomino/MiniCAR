# Keil uVision project MiniModelCar.uvprojx, settings and files
target MiniModelCar (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniModelCar +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\MiniModelCar_COER;..\STM32F10x_FWLib\inc;..\MiniModelCar_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MiniModelCar_HARDWARE\DMP;..\MiniModelCar_HARDWARE\IIC;..\MiniModelCar_HARDWARE\MPU6050;..\MiniModelCar_HARDWARE\ENCODER;..\MiniModelCar_HARDWARE\OLED;..\MiniModelCar\show;..\MiniModelCar_HARDWARE\LED;..\MiniModelCar_HARDWARE\KEY;..\MiniModelCar_HARDWARE\ADC;..\MiniModelCar_HARDWARE\MOTOR;..\MiniModelCar_HARDWARE\TIMER;..\MiniModelCar_HARDWARE\EXTI;..\MiniModelCar\DataScope_DP;..\MiniModelCar\filter;..\MiniModelCar_HARDWARE\STMFLASH;..\MiniModelCar_HARDWARE\USARTX;..\MiniModelCar_HARDWARE\NRF24L01;..\MiniModelCar_HARDWARE\SPI;..\MiniModelCar_HARDWARE\CAN;..\MiniModelCar_HARDWARE\PS2;..\MiniModelCar\CONTROL;..\MiniModelCar_HARDWARE\TrackLogic;..\MiniModelCar_HARDWARE\BINARY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c
  group CORE
    ../MiniModelCar_COER/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../MiniModelCar_HARDWARE/LED/: LED.C
    ../MiniModelCar_HARDWARE/KEY/: key.c
    ../MiniModelCar_HARDWARE/OLED/: oled.c
    ../MiniModelCar_HARDWARE/ADC/: adc.c
    ../MiniModelCar_HARDWARE/TIMER/: timer.c
    ../MiniModelCar_HARDWARE/MOTOR/: motor.c
    ../MiniModelCar_HARDWARE/ENCODER/: encoder.c
    ../MiniModelCar_HARDWARE/IIC/: IOI2C.c
    ../MiniModelCar_HARDWARE/EXTI/: exti.c
    ../MiniModelCar_HARDWARE/USARTX/: usartx.c
    ../MiniModelCar_HARDWARE/CAN/: can.c
    ../MiniModelCar_HARDWARE/PS2/: pstwo.c
    ../MiniModelCar_HARDWARE/TrackLogic/: TrackLogic.c
    ../MiniModelCar_HARDWARE/STMFLASH/: stmflash.c
  group MiniModelCar
    ../MiniModelCar/CONTROL/: control.c
    ../MiniModelCar/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MiniModelCar/filter/: filter.c
    ../MiniModelCar/MPU6050/: MPU6050.c
    ../MiniModelCar/show/: show.c
    ../MiniModelCar/DataScope_DP/: DataScope_DP.C
software components: CMSIS:CORE 5.5.0
